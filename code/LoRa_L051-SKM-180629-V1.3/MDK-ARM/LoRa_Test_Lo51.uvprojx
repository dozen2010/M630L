# Keil uVision project LoRa_Test_Lo51.uvprojx, settings and files
target LoRa_Test_Lo51 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: COO +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,USE_MODEM_LORA,COO
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Src;../Src/sx1276;../Src/Aware_Protocol;../Src/motion;../Src/LF;../Src/OHR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c common.c Flash.c tim.c coo_main.c
    ./: startup_stm32l051xx.s
    ../Src/sx1276/: hw_gpio.c hw_rtc.c hw_spi.c mlm32l07x01.c sx1276.c timeServer.c low_power.c
    ../Src/motion/: lptim.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group AwarePro
    ../Src/Aware_Protocol/: Aware_Protocol.c
  group LF
    ../Src/LF/: ccRFID_CRC8.c LF_AS3932.c LF_Protocol.c LFwakeup.c
  group OHR
    ../Src/OHR/: orh_uart.c ohr_i2c.c
target Router-L051 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: LoRa_Test_Lo51
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,USE_MODEM_LORA,Router
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Src;../Src/sx1276;../Src/Aware_Protocol;../Src/motion;../Src/LF
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
target ZED-L051 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MateTag
  AfterMake: fromelf.exe --bin -o ./LoRa_Test_Lo51/MateTag.bin ./LoRa_Test_Lo51/MateTag.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx,USE_MODEM_LORA,ZED
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Src;../Src/sx1276;../Src/Aware_Protocol;../Src/LF;../Src/motion;../Src/OHR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
